/**
 * @file    test_eskf_trajectory.c
 * @brief   Trajectory-based ESKF integration tests.
 *
 * Loads unified CSV sensor data generated by generate_trajectory.py,
 * feeds it to the ESKF, and compares output to ground truth.
 */
#include "unity.h"
#include "state_estimation/ekf.h"
#include "state_estimation/quaternion.h"
#include <math.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

/* ========================================================================
 * Unified CSV Loading
 * ====================================================================== */

#define MAX_EVENTS       16000
#define MAX_CONFIGS      32
#define MAX_CHANNELS     8

typedef struct {
    char key[48];
    char value[64];
} config_entry_t;

typedef struct {
    uint64_t timestamp_us;
    char sensor[8];
    uint8_t id;
    float d[3];
    float tq[4];
    float tp[3];
    float tv[3];
} unified_row_t;

static config_entry_t g_configs[MAX_CONFIGS];
static unified_row_t  g_rows[MAX_EVENTS];
static eskf_sample_t  g_sample_pool[MAX_EVENTS];

static size_t load_unified_csv(const char *path,
                               config_entry_t *configs, size_t *num_configs,
                               unified_row_t *rows, size_t max_rows)
{
    FILE *f = fopen(path, "r");
    if (!f) return 0;

    char line[512];
    *num_configs = 0;
    size_t n_rows = 0;

    while (fgets(line, sizeof(line), f)) {
        if (line[0] == '#') {
            /* Parse "# key=value" */
            char *eq = strchr(line + 2, '=');
            if (eq && *num_configs < MAX_CONFIGS) {
                size_t klen = (size_t)(eq - (line + 2));
                if (klen >= sizeof(configs[0].key)) klen = sizeof(configs[0].key) - 1;
                memcpy(configs[*num_configs].key, line + 2, klen);
                configs[*num_configs].key[klen] = '\0';

                char *val_start = eq + 1;
                /* Strip trailing newline */
                char *nl = strchr(val_start, '\n');
                if (nl) *nl = '\0';
                nl = strchr(val_start, '\r');
                if (nl) *nl = '\0';

                strncpy(configs[*num_configs].value, val_start,
                        sizeof(configs[0].value) - 1);
                configs[*num_configs].value[sizeof(configs[0].value) - 1] = '\0';
                (*num_configs)++;
            }
            continue;
        }

        /* Skip header line */
        if (strncmp(line, "timestamp", 9) == 0) continue;

        if (n_rows >= max_rows) break;

        /* Parse data row */
        unified_row_t *r = &rows[n_rows];
        long long t;
        char sensor_str[16];
        int id;

        int parsed = sscanf(line, "%lld,%[^,],%d,%f,%f,%f,%f,%f,%f,%f,%f,%f,%f,%f,%f,%f",
                            &t, sensor_str, &id,
                            &r->d[0], &r->d[1], &r->d[2],
                            &r->tq[0], &r->tq[1], &r->tq[2], &r->tq[3],
                            &r->tp[0], &r->tp[1], &r->tp[2],
                            &r->tv[0], &r->tv[1], &r->tv[2]);

        if (parsed == 16) {
            r->timestamp_us = (uint64_t)t;
            strncpy(r->sensor, sensor_str, sizeof(r->sensor) - 1);
            r->sensor[sizeof(r->sensor) - 1] = '\0';
            r->id = (uint8_t)id;
            n_rows++;
        }
    }
    fclose(f);
    return n_rows;
}

/* ========================================================================
 * Config Parsing
 * ====================================================================== */

static void parse_vec3(const char *str, float out[3], char sep)
{
    out[0] = out[1] = out[2] = 0.0f;
    sscanf(str, "%f%*c%f%*c%f", &out[0], &out[1], &out[2]);
    (void)sep;
}

static eskf_sensor_type_t sensor_type_from_str(const char *s)
{
    if (strcmp(s, "gyro") == 0)  return ESKF_SENSOR_GYRO;
    if (strcmp(s, "accel") == 0) return ESKF_SENSOR_ACCEL;
    if (strcmp(s, "gps") == 0)   return ESKF_SENSOR_GPS;
    if (strcmp(s, "baro") == 0)  return ESKF_SENSOR_BARO;
    if (strcmp(s, "mag") == 0)   return ESKF_SENSOR_MAG;
    return ESKF_SENSOR_COUNT;
}

static eskf_sensor_noise_config_t g_noise_configs[ESKF_MAX_SENSORS];

static void apply_config(const config_entry_t *configs, size_t num_configs,
                         eskf_config_t *cfg,
                         eskf_sensor_noise_config_t *noise_cfgs, size_t *num_noise)
{
    memset(cfg, 0, sizeof(*cfg));
    *num_noise = 0;

    /* Defaults */
    cfg->num_imus = 1;
    cfg->expected_g[2] = 1.0f;
    cfg->mag_ref[0] = 1.0f;

    /* Default process noise (continuous-time spectral density, scaled by dt
     * during prediction). Units: rad²/s for θ, (rad/s)²/s for bias. */
    for (int i = 0; i < 3; i++) cfg->orientation_process_noise[i][i] = 0.01f;
    for (int k = 0; k < ESKF_MAX_IMUS; k++) {
        for (int i = 0; i < 3; i++) {
            cfg->orientation_process_noise[3 + 6*k + i][3 + 6*k + i] = 1e-4f;
            cfg->orientation_process_noise[6 + 6*k + i][6 + 6*k + i] = 1e-4f;
        }
    }
    for (int i = 0; i < 3; i++) cfg->body_process_noise[i][i] = 100.0f;
    for (int i = 3; i < 6; i++) cfg->body_process_noise[i][i] = 10.0f;

    for (size_t c = 0; c < num_configs; c++) {
        const char *key = configs[c].key;
        const char *val = configs[c].value;

        if (strcmp(key, "calibration_samples") == 0) {
            cfg->calibration_samples = (uint32_t)atoi(val);
        } else if (strcmp(key, "expected_g") == 0) {
            parse_vec3(val, cfg->expected_g, ';');
        } else if (strcmp(key, "mag_ref") == 0) {
            parse_vec3(val, cfg->mag_ref, ';');
        } else if (strcmp(key, "num_imus") == 0) {
            cfg->num_imus = (uint8_t)atoi(val);
        } else if (strncmp(key, "sensor:", 7) == 0 && *num_noise < ESKF_MAX_SENSORS) {
            /* Parse "sensor:TYPE:ID:noise" */
            char type_str[16] = {0};
            int sid = 0;
            if (sscanf(key, "sensor:%[^:]:%d:noise", type_str, &sid) == 2) {
                eskf_sensor_noise_config_t *nc = &noise_cfgs[*num_noise];
                nc->type = sensor_type_from_str(type_str);
                nc->id = (uint8_t)sid;
                memset(nc->noise, 0, sizeof(nc->noise));

                /* Parse noise values */
                float n0 = 0, n1 = 0, n2 = 0;
                int np = sscanf(val, "%f;%f;%f", &n0, &n1, &n2);
                if (np >= 1) {
                    nc->noise[0][0] = n0 * n0; /* variance = std^2 */
                    if (np >= 2) nc->noise[1][1] = n1 * n1;
                    if (np >= 3) nc->noise[2][2] = n2 * n2;
                    if (np == 1) {
                        /* Scalar sensor (baro) — just R[0][0] */
                        nc->noise[0][0] = n0 * n0;
                    }
                }
                (*num_noise)++;
            }
        }
    }

    cfg->sensors = noise_cfgs;
    cfg->num_sensors = *num_noise;
}

/* ========================================================================
 * Channel Builder
 * ====================================================================== */

typedef struct {
    eskf_sensor_type_t type;
    uint8_t id;
    size_t start;  /* index into sample pool */
    size_t count;
} channel_info_t;

static size_t build_channels(const unified_row_t *rows, size_t n_rows,
                             eskf_sensor_channel_t *channels,
                             eskf_sample_t *pool, size_t pool_size)
{
    channel_info_t infos[MAX_CHANNELS];
    size_t n_channels = 0;

    /* Pass 1: discover channels and count samples per channel */
    for (size_t r = 0; r < n_rows; r++) {
        eskf_sensor_type_t type = sensor_type_from_str(rows[r].sensor);
        uint8_t id = rows[r].id;

        size_t ch = 0;
        for (; ch < n_channels; ch++) {
            if (infos[ch].type == type && infos[ch].id == id) break;
        }
        if (ch == n_channels) {
            if (n_channels >= MAX_CHANNELS) continue;
            infos[n_channels].type = type;
            infos[n_channels].id = id;
            infos[n_channels].count = 0;
            infos[n_channels].start = 0;
            n_channels++;
        }
        infos[ch].count++;
    }

    /* Assign contiguous pool regions */
    size_t offset = 0;
    for (size_t i = 0; i < n_channels; i++) {
        infos[i].start = offset;
        offset += infos[i].count;
    }

    /* Pass 2: fill pool with samples in per-channel contiguous order */
    size_t write_idx[MAX_CHANNELS];
    for (size_t i = 0; i < n_channels; i++)
        write_idx[i] = infos[i].start;

    for (size_t r = 0; r < n_rows; r++) {
        eskf_sensor_type_t type = sensor_type_from_str(rows[r].sensor);
        uint8_t id = rows[r].id;

        size_t ch = 0;
        for (; ch < n_channels; ch++) {
            if (infos[ch].type == type && infos[ch].id == id) break;
        }
        if (ch >= n_channels) continue;

        size_t idx = write_idx[ch];
        if (idx >= pool_size) continue;
        pool[idx].timestamp_us = rows[r].timestamp_us;
        pool[idx].data[0] = rows[r].d[0];
        pool[idx].data[1] = rows[r].d[1];
        pool[idx].data[2] = rows[r].d[2];
        write_idx[ch]++;
    }

    /* Build channel array */
    for (size_t i = 0; i < n_channels; i++) {
        channels[i].type = infos[i].type;
        channels[i].id = infos[i].id;
        channels[i].samples = &pool[infos[i].start];
        channels[i].count = infos[i].count;
    }

    return n_channels;
}

/* ========================================================================
 * Error Metrics
 * ====================================================================== */

static float quat_error_deg(const float a[4], const float b[4])
{
    float dot = a[0]*b[0] + a[1]*b[1] + a[2]*b[2] + a[3]*b[3];
    if (dot < 0) dot = -dot;
    if (dot > 1.0f) dot = 1.0f;
    return 2.0f * acosf(dot) * 180.0f / (float)M_PI;
}

/* ========================================================================
 * Helper: run a scenario from a unified CSV
 * ====================================================================== */

typedef struct {
    float att_err_deg;
    float pos_err_m;
    float q[4];
    float pos[3];
    float vel[3];
    float q_true[4];
    float pos_true[3];
    bool calibrated;
} test_result_t;

static test_result_t run_scenario(const char *csv_path)
{
    test_result_t result;
    memset(&result, 0, sizeof(result));

    size_t num_configs = 0;
    size_t n_rows = load_unified_csv(csv_path, g_configs, &num_configs,
                                     g_rows, MAX_EVENTS);
    TEST_ASSERT_GREATER_THAN(0, n_rows);

    /* Apply config */
    eskf_config_t cfg;
    size_t num_noise = 0;
    apply_config(g_configs, num_configs, &cfg, g_noise_configs, &num_noise);

    /* Build channels */
    eskf_sensor_channel_t channels[MAX_CHANNELS];
    size_t n_channels = build_channels(g_rows, n_rows, channels,
                                       g_sample_pool, MAX_EVENTS);
    TEST_ASSERT_GREATER_THAN(0, n_channels);

    /* Init and process */
    eskf_t eskf;
    eskf_init(&eskf, &cfg);

    eskf_input_t input = { channels, n_channels };
    eskf_process(&eskf, &input);

    result.calibrated = eskf_is_calibrated(&eskf);
    eskf_get_state(&eskf, result.q, result.pos, result.vel);

    /* Truth from last row */
    const unified_row_t *last = &g_rows[n_rows - 1];
    memcpy(result.q_true, last->tq, sizeof(float) * 4);
    memcpy(result.pos_true, last->tp, sizeof(float) * 3);

    result.att_err_deg = quat_error_deg(result.q, result.q_true);
    result.pos_err_m = sqrtf(
        (result.pos[0] - last->tp[0]) * (result.pos[0] - last->tp[0]) +
        (result.pos[1] - last->tp[1]) * (result.pos[1] - last->tp[1]) +
        (result.pos[2] - last->tp[2]) * (result.pos[2] - last->tp[2]));

    return result;
}

/* ========================================================================
 * Tests
 * ====================================================================== */

void test_trajectory_static(void)
{
    test_result_t r = run_scenario("test-data/static.csv");

    TEST_ASSERT_TRUE(r.calibrated);

    /* Quaternion near identity */
    TEST_ASSERT_FLOAT_WITHIN(5.0f, 0.0f, r.att_err_deg);

    /* Unit norm */
    float norm = sqrtf(r.q[0]*r.q[0] + r.q[1]*r.q[1] +
                       r.q[2]*r.q[2] + r.q[3]*r.q[3]);
    TEST_ASSERT_FLOAT_WITHIN(1e-4f, 1.0f, norm);
}

void test_trajectory_pitch_maneuver(void)
{
    test_result_t r = run_scenario("test-data/pitch_maneuver.csv");

    TEST_ASSERT_TRUE(r.calibrated);

    /* After 3s of 0.5 rad/s pitch (86 deg total), allow 10 deg error */
    TEST_ASSERT_FLOAT_WITHIN(10.0f, 0.0f, r.att_err_deg);
}

void test_trajectory_vertical_ascent(void)
{
    test_result_t r = run_scenario("test-data/vertical_ascent.csv");

    TEST_ASSERT_TRUE(r.calibrated);

    /* Orientation should stay near identity */
    TEST_ASSERT_FLOAT_WITHIN(10.0f, 0.0f, r.att_err_deg);

    /* Position error bounded by GPS + baro */
    TEST_ASSERT_FLOAT_WITHIN(50.0f, 0.0f, r.pos_err_m);
}

void test_trajectory_dual_imu_static(void)
{
    test_result_t r = run_scenario("test-data/dual_imu_static.csv");

    TEST_ASSERT_TRUE(r.calibrated);

    /* Quaternion near identity with 2 IMUs */
    TEST_ASSERT_FLOAT_WITHIN(5.0f, 0.0f, r.att_err_deg);
}

void test_trajectory_dual_baro_ascent(void)
{
    test_result_t r = run_scenario("test-data/dual_baro_ascent.csv");

    TEST_ASSERT_TRUE(r.calibrated);

    /* Orientation near identity */
    TEST_ASSERT_FLOAT_WITHIN(10.0f, 0.0f, r.att_err_deg);

    /* Position bounded */
    TEST_ASSERT_FLOAT_WITHIN(50.0f, 0.0f, r.pos_err_m);
}
